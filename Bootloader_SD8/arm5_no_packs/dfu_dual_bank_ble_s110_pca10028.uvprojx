# Keil uVision project dfu_dual_bank_ble_s110_pca10028.uvprojx, settings and files
target nrf51822_xxac (ARM-ADS)
  device: nRF51822_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: funiki_fw_13 +hex
  c flags: Optim=4
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 S110 NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\config\dfu_dual_bank_ble_s110_pca10028;..\config;..\components\libraries\bootloader_dfu;..\components\libraries\bootloader_dfu\ble_transport;..\components\softdevice\s110\headers;..\components\softdevice\common\softdevice_handler;..\components\libraries\timer;..\components\device;..\components\toolchain;..\components\libraries\crc16;..\components\libraries\util;..\components\ble\ble_services\ble_dfu;..\components\ble\common;..\components\libraries\hci;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\libraries\scheduler;..\components\drivers_nrf\twi_master\incubated
  library: MicroLIB
  memory RVCT4: ROM 0x3c000 size 0x3c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../: dfu_ble_svc.c main.c
  group Documentation
    ../: Abstract.txt license.txt
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../components/drivers_nrf/hal/: nrf_delay.c
    ../components/drivers_nrf/twi_master/incubated/: twi_sw_master.c
    ../components/drivers_nrf/pstorage/: pstorage.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c nrf_assert.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../components/libraries/bootloader_dfu/: bootloader.c bootloader_settings_arm.c bootloader_util_arm.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/hci/: hci_mem_pool.c
  group nRF_SoftDevice
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
software components: CMSIS:CORE 4.1.0, Device:Startup 7.2.1
