# Keil uVision project dfu_dual_bank_ble_s110_pca10028.uvprojx, settings and files
target nrf51822_s110_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: nrf51822_xxaa_bootstrap +hex
  c flags: Optim=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 BOARD_CUSTOM S110 BSP_DEFINES_ONLY NRF51 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --c99
  c include: ..\config\dfu_dual_bank_ble_s110_pca10028;..\config;..\bsp;..\components\toolchain;..\components\ble\ble_services\ble_dfu;..\components\ble\common;..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\pstorage;..\components\libraries\bootloader_dfu;..\components\libraries\bootloader_dfu\ble_transport;..\components\libraries\crc16;..\components\libraries\hci;..\components\libraries\scheduler;..\components\libraries\timer;..\components\libraries\util;..\components\softdevice\common\softdevice_handler;..\components\softdevice\s110\headers
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x3a000 size 0x5c00
  memory RVCT9: RAM 0x20002c00 size 0x1380
  memory RVCT10: RAM 0x20003f80 size 0x80
  group Application
    ../: dfu_ble_svc.c main.c
  group Documentation
    ../: Abstract.txt license.txt
  group nRF_BLE
    ../components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
    ../components/ble/ble_services/ble_dfu/: ble_dfu.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/pstorage/: pstorage_raw.c
  group nRF_Libraries
    ../components/libraries/util/: app_error.c nrf_assert.c
    ../components/libraries/scheduler/: app_scheduler.c
    ../components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../components/libraries/bootloader_dfu/: bootloader.c bootloader_settings.c bootloader_util.c dfu_dual_bank.c dfu_init_template.c dfu_transport_ble.c
    ../components/libraries/crc16/: crc16.c
    ../components/libraries/hci/: hci_mem_pool.c
  group nRF_SoftDevice
    ../../../../../../components/softdevice/s110/doc/: s110_nrf51_8.0.0_licence-agreement.txt
    ../components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
