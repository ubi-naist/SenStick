# Keil uVision project secure_dfu_secure_dfu_ble_s132_pca10040.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: CONFIG_NFCT_PINS_AS_GPIOS BOARD_CUSTOM BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1
  c include: ..\..\config;..\..\nRF5_SDK_12\components;..\..\nRF5_SDK_12\components\ble\common;..\..\nRF5_SDK_12\components\boards;..\..\nRF5_SDK_12\components\drivers_nrf\clock;..\..\nRF5_SDK_12\components\drivers_nrf\common;..\..\nRF5_SDK_12\components\drivers_nrf\delay;..\..\nRF5_SDK_12\components\drivers_nrf\hal;..\..\nRF5_SDK_12\components\drivers_nrf\rng;..\..\nRF5_SDK_12\components\libraries\bootloader;..\..\nRF5_SDK_12\components\libraries\bootloader\ble_dfu;..\..\nRF5_SDK_12\components\libraries\bootloader\dfu;..\..\nRF5_SDK_12\components\libraries\crc32;..\..\nRF5_SDK_12\components\libraries\crypto;..\..\nRF5_SDK_12\components\libraries\ecc;..\..\nRF5_SDK_12\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12\components\libraries\fstorage;..\..\nRF5_SDK_12\components\libraries\hci;..\..\nRF5_SDK_12\components\libraries\log;..\..\nRF5_SDK_12\components\libraries\log\src;..\..\nRF5_SDK_12\components\libraries\queue;..\..\nRF5_SDK_12\components\libraries\scheduler;..\..\nRF5_SDK_12\components\libraries\sha256;..\..\nRF5_SDK_12\components\libraries\svc;..\..\nRF5_SDK_12\components\libraries\timer;..\..\nRF5_SDK_12\components\libraries\util;..\..\nRF5_SDK_12\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12\components\softdevice\s132\headers;..\..\nRF5_SDK_12\components\softdevice\s132\headers\nrf52;..\..\nRF5_SDK_12\components\toolchain;..\..;..\..\nRF5_SDK_12\external\micro-ecc\micro-ecc;..\..\nRF5_SDK_12\external\nano-pb;..\config;..\bsp\
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 CONFIG_GPIO_AS_PINRESET NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: ..\..\config\secure_dfu_secure_dfu_ble_s132_pca10040;..\..\config;..\..\nRF5_SDK_12\components;..\..\nRF5_SDK_12\components\ble\common;..\..\nRF5_SDK_12\components\boards;..\..\nRF5_SDK_12\components\drivers_nrf\clock;..\..\nRF5_SDK_12\components\drivers_nrf\common;..\..\nRF5_SDK_12\components\drivers_nrf\delay;..\..\nRF5_SDK_12\components\drivers_nrf\hal;..\..\nRF5_SDK_12\components\drivers_nrf\rng;..\..\nRF5_SDK_12\components\libraries\bootloader;..\..\nRF5_SDK_12\components\libraries\bootloader\ble_dfu;..\..\nRF5_SDK_12\components\libraries\bootloader\dfu;..\..\nRF5_SDK_12\components\libraries\crc32;..\..\nRF5_SDK_12\components\libraries\crypto;..\..\nRF5_SDK_12\components\libraries\ecc;..\..\nRF5_SDK_12\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12\components\libraries\fstorage;..\..\nRF5_SDK_12\components\libraries\hci;..\..\nRF5_SDK_12\components\libraries\log;..\..\nRF5_SDK_12\components\libraries\log\src;..\..\nRF5_SDK_12\components\libraries\queue;..\..\nRF5_SDK_12\components\libraries\scheduler;..\..\nRF5_SDK_12\components\libraries\sha256;..\..\nRF5_SDK_12\components\libraries\svc;..\..\nRF5_SDK_12\components\libraries\timer;..\..\nRF5_SDK_12\components\libraries\util;..\..\nRF5_SDK_12\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12\components\softdevice\s132\headers;..\..\nRF5_SDK_12\components\softdevice\s132\headers\nrf52;..\..\nRF5_SDK_12\components\toolchain;..\..;..\..\nRF5_SDK_12\external\micro-ecc\micro-ecc;..\..\nRF5_SDK_12\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x78000 size 0x6000
  memory RVCT9: RAM 0x20002c00 size 0xd380
  group Application
    ../: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../nRF5_SDK_12/components/boards/: boards.c
  group Documentation
    ../: license.txt
  group nRF_BLE
    ../../nRF5_SDK_12/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../nRF5_SDK_12/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../../nRF5_SDK_12/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../../nRF5_SDK_12/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nRF5_SDK_12/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../nRF5_SDK_12/components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../../nRF5_SDK_12/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../nRF5_SDK_12/components/libraries/scheduler/: app_scheduler.c
    ../../nRF5_SDK_12/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../nRF5_SDK_12/components/libraries/crc32/: crc32.c
    ../../nRF5_SDK_12/components/libraries/ecc/: ecc.c
    ../../nRF5_SDK_12/components/libraries/fstorage/: fstorage.c
    ../../nRF5_SDK_12/components/libraries/hci/: hci_mem_pool.c
    ../../nRF5_SDK_12/components/libraries/crypto/: nrf_crypto.c
    ../../nRF5_SDK_12/components/libraries/queue/: nrf_queue.c
    ../../nRF5_SDK_12/components/libraries/sha256/: sha256.c
  group nRF_SoftDevice
    ../../nRF5_SDK_12/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_micro_ecc
    ../../nRF5_SDK_12/external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../nRF5_SDK_12/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
