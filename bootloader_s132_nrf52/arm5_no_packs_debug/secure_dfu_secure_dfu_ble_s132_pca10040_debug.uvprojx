# Keil uVision project secure_dfu_secure_dfu_ble_s132_pca10040_debug.uvprojx, settings and files
target nrf52832_xxaa_s132 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa_s132 +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: NRF_DFU_DEBUG_VERSION BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 CONFIG_GPIO_AS_PINRESET SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1
  c include: ..\config\secure_dfu_secure_dfu_ble_s132_pca10040_debug;..\config;..\..\nRF5_SDK_12\components;..\..\nRF5_SDK_12\components\ble\common;..\..\nRF5_SDK_12\components\drivers_nrf\clock;..\..\nRF5_SDK_12\components\drivers_nrf\common;..\..\nRF5_SDK_12\components\drivers_nrf\delay;..\..\nRF5_SDK_12\components\drivers_nrf\hal;..\..\nRF5_SDK_12\components\drivers_nrf\rng;..\..\nRF5_SDK_12\components\libraries\bootloader;..\..\nRF5_SDK_12\components\libraries\bootloader\ble_dfu;..\..\nRF5_SDK_12\components\libraries\bootloader\ble_dfu\includes;..\..\nRF5_SDK_12\components\libraries\bootloader\dfu;..\..\nRF5_SDK_12\components\libraries\crc32;..\..\nRF5_SDK_12\components\libraries\crypto;..\..\nRF5_SDK_12\components\libraries\ecc;..\..\nRF5_SDK_12\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12\components\libraries\fifo;..\..\nRF5_SDK_12\components\libraries\fstorage;..\..\nRF5_SDK_12\components\libraries\hci;..\..\nRF5_SDK_12\components\libraries\log;..\..\nRF5_SDK_12\components\libraries\log\src;..\..\nRF5_SDK_12\components\libraries\scheduler;..\..\nRF5_SDK_12\components\libraries\sha256;..\..\nRF5_SDK_12\components\libraries\svc;..\..\nRF5_SDK_12\components\libraries\timer;..\..\nRF5_SDK_12\components\libraries\util;..\..\nRF5_SDK_12\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12\components\softdevice\s132\headers;..\..\nRF5_SDK_12\components\softdevice\s132\headers\nrf52;..\..\nRF5_SDK_12\components\toolchain;..\bsp;..\..;..\..\nRF5_SDK_12\external\micro-ecc\micro-ecc;..\..\nRF5_SDK_12\external\nano-pb;..\..\nRF5_SDK_12\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DNRF_DFU_DEBUG_VERSION,-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DCONFIG_GPIO_AS_PINRESET,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x73000 size 0xb000
  memory RVCT9: RAM 0x20002c00 size 0xd380
  group Application
    ../: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c
    ../config/: sdk_config.h
  group Documentation
    ../: license.txt
  group nRF_BLE
    ../../nRF5_SDK_12/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group nRF_BLE_DFU
    ../../nRF5_SDK_12/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group nRF_Bootloader
    ../../nRF5_SDK_12/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../../nRF5_SDK_12/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group nRF_Drivers
    ../../nRF5_SDK_12/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nRF5_SDK_12/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../nRF5_SDK_12/components/drivers_nrf/hal/: nrf_nvmc.c
  group nRF_Libraries
    ../../nRF5_SDK_12/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c
    ../../nRF5_SDK_12/components/libraries/fifo/: app_fifo.c
    ../../nRF5_SDK_12/components/libraries/scheduler/: app_scheduler.c
    ../../nRF5_SDK_12/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../nRF5_SDK_12/components/libraries/crc32/: crc32.c
    ../../nRF5_SDK_12/components/libraries/ecc/: ecc.c
    ../../nRF5_SDK_12/components/libraries/fstorage/: fstorage.c
    ../../nRF5_SDK_12/components/libraries/hci/: hci_mem_pool.c
    ../../nRF5_SDK_12/components/libraries/crypto/: nrf_crypto.c
    ../../nRF5_SDK_12/components/libraries/sha256/: sha256.c
  group nRF_Log
    ../../nRF5_SDK_12/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../nRF5_SDK_12/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../nRF5_SDK_12/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group nRF_micro_ecc
    ../../nRF5_SDK_12/external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group nano-pb
    ../../nRF5_SDK_12/external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
