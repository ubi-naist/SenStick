# Keil uVision project ble_app_template_s130_pca10028.uvprojx, settings and files
target nrf51822_xxac_s13(debug) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: senstick_xxac_s130_debug +hex
  c flags: Optim=1 OneElfS=1
  c define: ENABLE_RRT_DEBUG BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD S130 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x12000
  memory RVCT9: RAM 0x20002800 size 0x1800
  group senstick
    ../: main.c senstick_core_manager.c senstick_data_models.c senstick_gatt_service.c
  group twi
    ../: twi_slave_uvsensor.c twi_slave_rtc.c twi_slave_pressure_sensor.c twi_slave_humidity_sensor.c twi_slave_brightness_sensor.c twi_slave_acceleration_sensor.c
  group spi
    ../: spi_slave_flash_memory.c
  group gpio
    ../: gpio_uart.c gpio_led_driver.c gpio_button_monitoring.c gpio_battery_monitor.c
  group ble
    ../: ble_connection_parameter_manager.c ble_advertising_manager.c
  group rtt
    ../RTT_Implementation_141217/RTT/: SEGGER_RTT.c
target nrf51822_xxac_s130(release) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: nrf51422_xxac_s130 +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD S130 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1c000 size 0x24000
  memory RVCT9: RAM 0x20002800 size 0x5800
target flash_s130_nrf51_1.0.0_softdevice (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0
