# Keil uVision project senstick_xxaa_s110_sdk10.uvprojx, settings and files
target nrf51822_xxaa_s110(debug) (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: senstick_xxaa_s110_debug +hex
  c flags: Optim=2 OneElfS=1
  c define: DEBUG_NRF_USER DOXYGEN NRF_LOG_USES_RTT=1 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99
  c include: ..\..\firmware;..\segger_rtt
  asm define: BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 __HEAP_SIZE=0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x14000
  memory RVCT9: RAM 0x20002300 size 0x1d00
  group senstick
    ../: main.c senstick_data_models.c ble_logger_service.c ble_ti_sensortag_service.c senstick_tests.c
  group twi
    ../: twi_sensor_manager.c twi_slave_utility.c twi_slave_rtc.c twi_slave_pressure_sensor.c twi_slave_humidity_sensor.c twi_slave_brightness_sensor.c twi_slave_nine_axes_sensor.c twi_slave_uv_sensor.c
  group spi
    ../: spi_slave_mx25_flash_memory.c
  group gpio
    ../: gpio_manager.c gpio_uart.c gpio_led_driver.c gpio_button_monitoring.c gpio_battery_monitor.c
  group rtt
    ../segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group logger
    ../: test_storage.c sensor_data_storage.c flash_stream.c
target flash_s110_nrf51_8.0.3_softdevice (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.2.0
  cpu: as above
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 4.3.0, Device:Startup 8.2.0, nRF_BLE:BLE_Modules:ble_advdata 3.1.0, nRF_BLE:BLE_Modules:ble_advertising 3.1.0, nRF_BLE:BLE_Modules:ble_common 3.1.0, nRF_BLE:BLE_Modules:ble_conn_params 3.1.0, nRF_BLE:BLE_Modules:ble_db_discovery 3.1.0, nRF_BLE:BLE_Modules:ble_service_common 3.1.0, nRF_BLE:BLE_Modules:device_manager 3.1.0, nRF_BLE:BLE_Services:ble_bas 3.1.0, nRF_BLE:BLE_Services:ble_dfu 3.1.0, nRF_BLE:BLE_Services:ble_dis 3.1.0, nRF_BLE:BLE_Services:ble_lbs 3.1.0, nRF_BLE:BLE_Services:ble_nus 3.1.0, nRF_BLE:BLE_Services:ble_tps 3.1.0, nRF_Drivers:app_uart 3.1.0, nRF_Drivers:nrf_adc 3.1.0, nRF_Drivers:nrf_clock 3.1.0, nRF_Drivers:nrf_delay 3.1.0, nRF_Drivers:nrf_drv_clock 3.1.0, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Drivers:nrf_drv_gpiote 3.1.0, nRF_Drivers:nrf_drv_spi 3.1.0, nRF_Drivers:nrf_drv_twi 3.1.0, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Drivers:nrf_error 3.1.0, nRF_Drivers:nrf_gpio 3.1.0, nRF_Drivers:nrf_gpiote 3.1.0, nRF_Drivers:nrf_spi 3.1.0, nRF_Drivers:nrf_spim 3.1.0, nRF_Drivers:nrf_twi 3.1.0, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_uarte 3.1.0, nRF_Drivers:pstorage 3.1.0, nRF_Libraries:app_error 3.1.0, nRF_Libraries:app_scheduler 3.1.0, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:app_timer_with_app_scheduler 3.1.0, nRF_Libraries:app_trace 3.1.0, nRF_Libraries:app_util 3.1.0, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:nrf_assert 3.1.0, nRF_Libraries:nrf_log 3.1.0, nRF_Libraries:retarget 3.1.0, nRF_SoftDevice:Internal:sd_common 1.1.5, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.5, nRF_SoftDevice:Internal:softdevice_present 1.1.5, nRF_SoftDevice:s110 8.0.3
