# Keil uVision project senstick_xxaa_s110_sdk10.uvprojx, settings and files
target nrf51822_xxaa_s110(debug) (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: senstick_xxaa_s110_debug +hex
  c flags: Optim=2 OneElfS=1
  c define: DEBUG_NRF_USER DOXYGEN NRF_LOG_USES_RTT=1 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99  --info=stack
  c include: ..\segger_rtt;..\
  asm define: BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0 __HEAP_SIZE=0
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x14000
  memory RVCT9: RAM 0x20002680 size 0x1980
  group senstick
    ../: main.c senstick_data_model.c
  group rtt
    ../segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group controller
    ../: metadata_log_controller.c
  group utils
    ../: value_types.c senstick_types.c
  group module
    ../: advertising_manager.c ble_stack.c app_gap.c senstick_device_manager.c
  group services
    ../: battery_service.c device_information_service.c
  group senstick_service
    ../: senstick_meta_data_service.c senstick_control_service.c service_util.c
  group sensor_controllers
    ../: log_controller.c senstick_sensor_controller.c sensor_service.c acceleration_sensor_base.c senstick_sensor_base_data.c gyro_sensor_base.c magnetic_sensor_base.c brightness_sensor_base.c uv_sensor_base.c humidity_sensor_base.c pressure_sensor_base.c
  group twi
    ../: twi_manager.c twi_slave_rtc.c twi_slave_nine_axes_sensor.c twi_slave_brightness_sensor.c twi_slave_uv_sensor.c twi_slave_humidity_sensor.c twi_slave_pressure_sensor.c
  group spi
    ../: spi_slave_mx25_flash_memory.c
  group gpio
    ../: gpio_led_driver.c gpio_button_monitoring.c
  group test
    ../: test_storage.c
target flash_s110_nrf51_8.0.3_softdevice (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: s130_nrf51_1.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1
  c define: BLE_STACK_SUPPORT_REQD NRF51
  c misc: --c99
  asm define: BLE_STACK_SUPPORT_REQD NRF51
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
target nrf51822_xxaa_s110(release) (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: senstick_xxaa_s110_release +hex
  c flags: Optim=4 OneElfS=1
  c define: DEBUG_NRF_USER DOXYGEN NRF_LOG_USES_RTT=0 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99  --info=stack
  c include: ..\;..\segger_rtt
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x14000
  memory RVCT9: RAM 0x20002680 size 0x1980
target nrf51822_xxaa_s110_pana(release) (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.9.0
  cpu: as above
  output: senstick_xxaa_s110_debug +hex
  c flags: Optim=4 oTime=1 OneElfS=1
  c define: PANASONIC DEBUG_NRF_USER DOXYGEN NRF_LOG_USES_RTT=1 BLE_STACK_SUPPORT_REQD S110 SOFTDEVICE_PRESENT NRF51 SWI_DISABLE0
  c misc: --c99 --info=stack
  c include: ..\segger_rtt;..\
  asm define: as above
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x14000
  memory RVCT9: RAM 0x20002680 size 0x1980
software components: CMSIS:CORE 5.0.0, CMSIS:CORE 4.3.0, Device:Startup 8.2.0, Device:Startup 8.7.1, nRF_BLE:BLE_Modules:ble_advdata 3.1.0, nRF_BLE:BLE_Modules:ble_advdata 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_advertising 3.1.0, nRF_BLE:BLE_Modules:ble_advertising 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_common 3.1.0, nRF_BLE:BLE_Modules:ble_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_conn_params 3.1.0, nRF_BLE:BLE_Modules:ble_conn_params 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_db_discovery 3.1.0, nRF_BLE:BLE_Modules:ble_db_discovery 4.0.0-2.alpha, nRF_BLE:BLE_Modules:ble_service_common 3.1.0, nRF_BLE:BLE_Modules:ble_service_common 4.0.0-2.alpha, nRF_BLE:BLE_Modules:device_manager 3.1.0, nRF_BLE:BLE_Modules:device_manager 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_bas 3.1.0, nRF_BLE:BLE_Services:ble_bas 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dfu 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_dis 3.1.0, nRF_BLE:BLE_Services:ble_dis 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_lbs 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_nus 4.0.0-2.alpha, nRF_BLE:BLE_Services:ble_tps 4.0.0-2.alpha, nRF_Drivers:app_uart 3.1.0, nRF_Drivers:app_uart 4.0.0-2.alpha, nRF_Drivers:nrf_adc 3.1.0, nRF_Drivers:nrf_adc 4.0.0-2.alpha, nRF_Drivers:nrf_clock 3.1.0, nRF_Drivers:nrf_clock 4.0.0-2.alpha, nRF_Drivers:nrf_delay 3.1.0, nRF_Drivers:nrf_delay 4.0.0-2.alpha, nRF_Drivers:nrf_drv_clock 3.1.0, nRF_Drivers:nrf_drv_clock 4.0.0-2.alpha, nRF_Drivers:nrf_drv_common 3.1.0, nRF_Drivers:nrf_drv_common 4.0.0-2.alpha, nRF_Drivers:nrf_drv_gpiote 3.1.0, nRF_Drivers:nrf_drv_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_drv_spi 3.1.0, nRF_Drivers:nrf_drv_spi 4.0.0-2.alpha, nRF_Drivers:nrf_drv_twi 3.1.0, nRF_Drivers:nrf_drv_twi 4.0.0-2.alpha, nRF_Drivers:nrf_drv_uart 3.1.0, nRF_Drivers:nrf_drv_uart 4.0.0-2.alpha, nRF_Drivers:nrf_error 3.1.0, nRF_Drivers:nrf_error 4.0.0-2.alpha, nRF_Drivers:nrf_gpio 3.1.0, nRF_Drivers:nrf_gpio 4.0.0-2.alpha, nRF_Drivers:nrf_gpiote 3.1.0, nRF_Drivers:nrf_gpiote 4.0.0-2.alpha, nRF_Drivers:nrf_spi 3.1.0, nRF_Drivers:nrf_spi 4.0.0-2.alpha, nRF_Drivers:nrf_spim 3.1.0, nRF_Drivers:nrf_spim 4.0.0-2.alpha, nRF_Drivers:nrf_twi 3.1.0, nRF_Drivers:nrf_twi 4.0.0-2.alpha, nRF_Drivers:nrf_uart 3.1.0, nRF_Drivers:nrf_uart 4.0.0-2.alpha, nRF_Drivers:nrf_uarte 3.1.0, nRF_Drivers:nrf_uarte 4.0.0-2.alpha, nRF_Drivers:pstorage 3.1.0, nRF_Drivers:pstorage 4.0.0-2.alpha, nRF_Libraries:DFU:dfu_app_handler 4.0.0-2.alpha, nRF_Libraries:DFU:dfu_bootloader_util 3.1.0, nRF_Libraries:DFU:dfu_bootloader_util 4.0.0-2.alpha, nRF_Libraries:Internal:app_mailbox 3.1.0, nRF_Libraries:Internal:app_mailbox 4.0.0-2.alpha, nRF_Libraries:app_button 3.1.0, nRF_Libraries:app_button 4.0.0-2.alpha, nRF_Libraries:app_error 3.1.0, nRF_Libraries:app_error 4.0.0-2.alpha, nRF_Libraries:app_scheduler 3.1.0, nRF_Libraries:app_scheduler 4.0.0-2.alpha, nRF_Libraries:app_timer 3.1.0, nRF_Libraries:app_timer 4.0.0-2.alpha, nRF_Libraries:app_timer_with_app_scheduler 3.1.0, nRF_Libraries:app_timer_with_app_scheduler 4.0.0-2.alpha, nRF_Libraries:app_trace 3.1.0, nRF_Libraries:app_trace 4.0.0-2.alpha, nRF_Libraries:app_util 3.1.0, nRF_Libraries:app_util 4.0.0-2.alpha, nRF_Libraries:nordic_common 3.1.0, nRF_Libraries:nordic_common 4.0.0-2.alpha, nRF_Libraries:nrf_assert 3.1.0, nRF_Libraries:nrf_assert 4.0.0-2.alpha, nRF_Libraries:nrf_log 3.1.0, nRF_Libraries:nrf_log 4.0.0-2.alpha, nRF_Libraries:retarget 3.1.0, nRF_Libraries:retarget 4.0.0-2.alpha, nRF_SoftDevice:Internal:sd_common 1.1.5, nRF_SoftDevice:Internal:sd_common 2.0.0-2.alpha, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 1.1.5, nRF_SoftDevice:Internal:sd_handler_with_app_scheduler 2.0.0-2.alpha, nRF_SoftDevice:Internal:softdevice_present 1.1.5, nRF_SoftDevice:Internal:softdevice_present 2.0.0-2.alpha, nRF_SoftDevice:s110 8.0.3
