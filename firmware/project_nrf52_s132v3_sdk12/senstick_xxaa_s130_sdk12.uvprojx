# Keil uVision project senstick_xxaa_s130_sdk12.uvprojx, settings and files
target nrf52832_xxaa (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: NRF_DFU_SETTINGS_VERSION=1 USE_APP_CONFIG CONFIG_NFCT_PINS_AS_GPIOS BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  c include: ..\;..\nrf52_s132v3_sdk12;..\..\nRF5_SDK_12\components\softdevice\s132\headers\;..\..\nRF5_SDK_12\components\softdevice\common\softdevice_handler\;..\..\nRF5_SDK_12\components\ble\common\;..\..\nRF5_SDK_12\components\ble\peer_manager\;..\..\nRF5_SDK_12\components\ble\ble_services\ble_bas\;..\..\nRF5_SDK_12\components\ble\ble_services\ble_dis\;..\..\nRF5_SDK_12\components\libraries\util\;..\..\nRF5_SDK_12\components\libraries\timer\;..\..\nRF5_SDK_12\components\libraries\fstorage\;..\..\nRF5_SDK_12\components\libraries\log\;..\..\nRF5_SDK_12\components\libraries\fds\;..\..\nRF5_SDK_12\components\libraries\log\src\;..\..\nRF5_SDK_12\components\libraries\button\;..\..\nRF5_SDK_12\components\libraries\mailbox\;..\..\nRF5_SDK_12\components\libraries\scheduler\;..\..\nRF5_SDK_12\components\libraries\experimental_section_vars\;..\..\nRF5_SDK_12\components\drivers_nrf\gpiote\;..\..\nRF5_SDK_12\components\drivers_nrf\hal\;..\..\nRF5_SDK_12\components\drivers_nrf\common\;..\..\nRF5_SDK_12\components\drivers_nrf\delay\;..\..\nRF5_SDK_12\components\drivers_nrf\clock\;..\..\nRF5_SDK_12\components\drivers_nrf\saadc\;..\..\nRF5_SDK_12\components\drivers_nrf\twi_master\;..\..\nRF5_SDK_12\components\drivers_nrf\spi_master\;..\..\nRF5_SDK_12\components\ble\ble_advertising\;..\..\nRF5_SDK_12\external\segger_rtt\;..\..\nRF5_SDK_12\components\libraries\bootloader\dfu\;..\..\nRF5_SDK_12\components\softdevice\s132\headers\nrf52\;..\..\nRF5_SDK_12\components\libraries\crc32\;..\..\nRF5_SDK_12\components\drivers_nrf\power\;..\..\nRF5_SDK_12\components\drivers_nrf\rng\
  asm define: BLE_STACK_SUPPORT_REQD S132 NRF_SD_BLE_API_VERSION=3 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_30 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 NRF52_PAN_53 NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_62 NRF52_PAN_63 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 SWI_DISABLE0
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DS132,-DNRF_SD_BLE_API_VERSION=3,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_30,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_53,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_62,-DNRF52_PAN_63,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DSWI_DISABLE0
  asm include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\..\nRF5_SDK_12\components;..\..\nRF5_SDK_12\components\ble\ble_advertising;..\..\nRF5_SDK_12\components\ble\ble_dtm;..\..\nRF5_SDK_12\components\ble\ble_racp;..\..\nRF5_SDK_12\components\ble\ble_services\ble_ancs_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_ans_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_bas;..\..\nRF5_SDK_12\components\ble\ble_services\ble_bas_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_cscs;..\..\nRF5_SDK_12\components\ble\ble_services\ble_cts_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_dfu;..\..\nRF5_SDK_12\components\ble\ble_services\ble_dis;..\..\nRF5_SDK_12\components\ble\ble_services\ble_gls;..\..\nRF5_SDK_12\components\ble\ble_services\ble_hids;..\..\nRF5_SDK_12\components\ble\ble_services\ble_hrs;..\..\nRF5_SDK_12\components\ble\ble_services\ble_hrs_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_hts;..\..\nRF5_SDK_12\components\ble\ble_services\ble_ias;..\..\nRF5_SDK_12\components\ble\ble_services\ble_ias_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_lbs;..\..\nRF5_SDK_12\components\ble\ble_services\ble_lbs_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_lls;..\..\nRF5_SDK_12\components\ble\ble_services\ble_nus;..\..\nRF5_SDK_12\components\ble\ble_services\ble_nus_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_rscs;..\..\nRF5_SDK_12\components\ble\ble_services\ble_rscs_c;..\..\nRF5_SDK_12\components\ble\ble_services\ble_tps;..\..\nRF5_SDK_12\components\ble\common;..\..\nRF5_SDK_12\components\ble\nrf_ble_qwr;..\..\nRF5_SDK_12\components\ble\peer_manager;..\..\nRF5_SDK_12\components\drivers_nrf\adc;..\..\nRF5_SDK_12\components\drivers_nrf\clock;..\..\nRF5_SDK_12\components\drivers_nrf\common;..\..\nRF5_SDK_12\components\drivers_nrf\comp;..\..\nRF5_SDK_12\components\drivers_nrf\delay;..\..\nRF5_SDK_12\components\drivers_nrf\gpiote;..\..\nRF5_SDK_12\components\drivers_nrf\hal;..\..\nRF5_SDK_12\components\drivers_nrf\i2s;..\..\nRF5_SDK_12\components\drivers_nrf\lpcomp;..\..\nRF5_SDK_12\components\drivers_nrf\pdm;..\..\nRF5_SDK_12\components\drivers_nrf\ppi;..\..\nRF5_SDK_12\components\drivers_nrf\pwm;..\..\nRF5_SDK_12\components\drivers_nrf\qdec;..\..\nRF5_SDK_12\components\drivers_nrf\rng;..\..\nRF5_SDK_12\components\drivers_nrf\rtc;..\..\nRF5_SDK_12\components\drivers_nrf\saadc;..\..\nRF5_SDK_12\components\drivers_nrf\spi_master;..\..\nRF5_SDK_12\components\drivers_nrf\spi_slave;..\..\nRF5_SDK_12\components\drivers_nrf\swi;..\..\nRF5_SDK_12\components\drivers_nrf\timer;..\..\nRF5_SDK_12\components\drivers_nrf\twi_master;..\..\nRF5_SDK_12\components\drivers_nrf\twis_slave;..\..\nRF5_SDK_12\components\drivers_nrf\uart;..\..\nRF5_SDK_12\components\drivers_nrf\wdt;..\..\nRF5_SDK_12\components\libraries\button;..\..\nRF5_SDK_12\components\libraries\crc16;..\..\nRF5_SDK_12\components\libraries\crc32;..\..\nRF5_SDK_12\components\libraries\csense;..\..\nRF5_SDK_12\components\libraries\csense_drv;..\..\nRF5_SDK_12\components\libraries\experimental_section_vars;..\..\nRF5_SDK_12\components\libraries\fds;..\..\nRF5_SDK_12\components\libraries\fifo;..\..\nRF5_SDK_12\components\libraries\fstorage;..\..\nRF5_SDK_12\components\libraries\hardfault;..\..\nRF5_SDK_12\components\libraries\hci;..\..\nRF5_SDK_12\components\libraries\led_softblink;..\..\nRF5_SDK_12\components\libraries\log;..\..\nRF5_SDK_12\components\libraries\log\src;..\..\nRF5_SDK_12\components\libraries\low_power_pwm;..\..\nRF5_SDK_12\components\libraries\mailbox;..\..\nRF5_SDK_12\components\libraries\mem_manager;..\..\nRF5_SDK_12\components\libraries\pwm;..\..\nRF5_SDK_12\components\libraries\scheduler;..\..\nRF5_SDK_12\components\libraries\sensorsim;..\..\nRF5_SDK_12\components\libraries\slip;..\..\nRF5_SDK_12\components\libraries\timer;..\..\nRF5_SDK_12\components\libraries\twi;..\..\nRF5_SDK_12\components\libraries\uart;..\..\nRF5_SDK_12\components\libraries\util;..\..\nRF5_SDK_12\components\softdevice\common\softdevice_handler;..\..\nRF5_SDK_12\components\softdevice\s132\headers;..\..\nRF5_SDK_12\components\softdevice\s132\headers\nrf52;..\..\nRF5_SDK_12\components\toolchain;..\..\..\..\..\bsp;..\..\nRF5_SDK_12\external\segger_rtt;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20003128 size 0xced8
  group nRF_BLE
    ../../nRF5_SDK_12/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../nRF5_SDK_12/components/ble/ble_advertising/: ble_advertising.c
    ../../nRF5_SDK_12/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_Drivers
    ../../nRF5_SDK_12/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../nRF5_SDK_12/components/drivers_nrf/common/: nrf_drv_common.c
    ../../nRF5_SDK_12/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../nRF5_SDK_12/components/drivers_nrf/uart/: nrf_drv_uart.c
    ../../nRF5_SDK_12/components/drivers_nrf/saadc/: nrf_drv_saadc.c
    ../../nRF5_SDK_12/components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../../nRF5_SDK_12/components/drivers_nrf/twi_master/: nrf_drv_twi.c
    ../../nRF5_SDK_12/components/drivers_nrf/hal/: nrf_saadc.c nrf_nvmc.c
    ../../nRF5_SDK_12/components/libraries/bootloader/dfu/: nrf_dfu_settings.c nrf_dfu_flash.c
  group nRF_Libraries
    ../../nRF5_SDK_12/components/libraries/button/: app_button.c
    ../../nRF5_SDK_12/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
    ../../nRF5_SDK_12/components/libraries/fifo/: app_fifo.c
    ../../nRF5_SDK_12/components/libraries/timer/: app_timer_appsh.c app_timer.c
    ../../nRF5_SDK_12/components/libraries/crc16/: crc16.c
    ../../nRF5_SDK_12/components/libraries/hardfault/: hardfault_implementation.c
    ../../nRF5_SDK_12/components/libraries/sensorsim/: sensorsim.c
    ../../nRF5_SDK_12/components/libraries/mailbox/: app_mailbox.c
    ../../nRF5_SDK_12/components/libraries/scheduler/: app_scheduler.c
    ../../nRF5_SDK_12/components/libraries/fds/: fds.c
    ../../nRF5_SDK_12/components/libraries/crc32/: crc32.c
    ../../nRF5_SDK_12/components/libraries/fstorage/: fstorage.c
  group nRF_Log
    ../../nRF5_SDK_12/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../nRF5_SDK_12/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../nRF5_SDK_12/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group senstick
    ../: main.c senstick_data_model.c
  group controller
    ../: metadata_log_controller.c
  group utils
    ../: value_types.c senstick_types.c
  group module
    ../: advertising_manager.c
  group services
    ../: device_information_service.c
    ../../nRF5_SDK_12/components/ble/ble_services/ble_bas/: ble_bas.c
    ../../nRF5_SDK_12/components/ble/ble_services/ble_dis/: ble_dis.c
  group senstick_service
    ../: senstick_meta_data_service.c senstick_control_service.c service_util.c
  group sensor_controller
    ../: log_controller.c senstick_sensor_controller.c sensor_service.c acceleration_sensor_base.c senstick_sensor_base_data.c gyro_sensor_base.c magnetic_sensor_base.c brightness_sensor_base.c uv_sensor_base.c humidity_sensor_base.c pressure_sensor_base.c
  group twi
    ../: twi_slave_brightness_sensor.c twi_slave_humidity_sensor.c twi_slave_nine_axes_sensor.c twi_slave_pressure_sensor.c twi_slave_uv_sensor.c
  group spi
    ../: spi_slave_mx25_flash_memory.c
  group gpio
    ../: gpio_button_monitoring.c gpio_led_driver.c
  group nrf52_s132v3_sdk12
    ../nrf52_s132v3_sdk12/: ble_stack.c senstick_peer_manager.c app_gap.c battery_service.c twi_manager.c twi_slave_rtc.c
  group test
    ../: test_storage.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.11.1
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_app_template_pca10040_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
